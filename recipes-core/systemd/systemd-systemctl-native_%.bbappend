CFLAGS:append = " -Wno-error=override-init"
BUILD_CFLAGS:append = " -Wno-error=override-init"