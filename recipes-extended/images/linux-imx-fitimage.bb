# meta-imx93frdm/recipes-kernel/linux/linux-imx-fitimage.bb
require recipes-kernel/linux/linux-yocto-fitimage.bb